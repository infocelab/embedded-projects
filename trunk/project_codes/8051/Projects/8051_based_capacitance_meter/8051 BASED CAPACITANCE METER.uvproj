# Keil uVision project 8051 BASED CAPACITANCE METER.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89LS52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(16000000) MODP2
  output: 8051 BASED CAPACITANCE METER +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 8051 BASED CAPACITANCE METER.c
